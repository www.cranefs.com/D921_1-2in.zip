# Autodesk Inventor part: D921_1-2inA
## iProperties
Created: 2011-03
Part Number: D921_1-2inA
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
